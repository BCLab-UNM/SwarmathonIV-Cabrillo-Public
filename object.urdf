Commit message: made the my_cylinder have less mass and Orange

File: object.urdf (robot description, URDF)
Before this commit: robot simple_box, 1 links, 0 joints
Links:
- link my_cylinder: mass 1.0 -> 0.1
